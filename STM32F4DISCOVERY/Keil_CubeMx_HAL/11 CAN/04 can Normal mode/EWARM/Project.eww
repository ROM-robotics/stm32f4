<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\04 can Normal mode.ewp</path>
  </project>
  <batchBuild />
</workspace>
